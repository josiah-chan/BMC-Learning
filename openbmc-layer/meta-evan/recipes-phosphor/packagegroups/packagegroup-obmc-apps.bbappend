RDEPENDS:${PN}-extras:append:${MACHINE}= " tree ipmitool"
